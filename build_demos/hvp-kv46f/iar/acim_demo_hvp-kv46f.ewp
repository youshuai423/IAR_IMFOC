# IAR project acim_demo_hvp-kv46f.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV46F128xxx15 Freescale MKV46F128xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MKV46F256VLL15=1; CLOCK_SETUP=5; ARM_MATH_CM4=1; DEMO=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe177
  ICCARM.CCIncludePath2: ../../../src/common/meterlib/CM4_4.0/fraclib; ../../../src/common/meterlib/CM4_4.0/fraclib/Include; ../../../src/common/meterlib/CM4_4.0/meterlib; ../../../src/common/meterlib/CM4_4.0/meterlib/Include; ../../../src/common/meterlib/CM4_4.0/meterliblp; ../../../src/common/meterlib/CM4_4.0/meterliblp/Include; ../../../src/common/fslesl/CM4_4.2/amclib; ../../../src/common/fslesl/CM4_4.2/amclib/Include; ../../../src/common/fslesl/CM4_4.2/gdflib; ../../../src/common/fslesl/CM4_4.2/gdflib/Include; ../../../src/common/fslesl/CM4_4.2/gflib; ../../../src/common/fslesl/CM4_4.2/gflib/Include; ../../../src/common/fslesl/CM4_4.2/gmclib; ../../../src/common/fslesl/CM4_4.2/gmclib/Include; ../../../src/common/fslesl/CM4_4.2/mlib; ../../../src/common/fslesl/CM4_4.2/mlib/Include; ../../../src/common/sdk/devices/MKV46F15/startup/iar; ../../../src/common/sdk/devices/MKV46F15/startup; ../../../src/projects/hvp-kv46f/board; ../../../src/projects/hvp-kv46f; ../../../src/common/mc_identification/src_routines; ../../../src/common/mc_identification/src_common; ../../../src/common/freemaster_drv; ../../../src/common/state_machine; ../../../src/common/mc_algorithms; ../../../src/common/mc_state_machine; ../../../src/common/mc_drivers; ../../../src/common/sdk/cmsis/Include; ../../../src/common/sdk/devices/MKV46F15/include; ../../../src/common/sdk/devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: acim_demo.srec
  ILINK.IlinkOutputFile: acim_demo.out
  ILINK.IlinkIcfFile: ../../../src/common/sdk/devices/MKV46F15/linker/iar/MKV46F256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../src/common/meterlib/CM4_4.0/libFRACLIB_iar.a; ../../../src/common/meterlib/CM4_4.0/libMETERLIB_iar.a; ../../../src/common/meterlib/CM4_4.0/libMETERLIBLP_iar.a; ../../../src/common/fslesl/CM4_4.2/libAMCLIB_ACIM_iar.a; ../../../src/common/fslesl/CM4_4.2/libAMCLIB_iar.a; ../../../src/common/fslesl/CM4_4.2/libGDFLIB_iar.a; ../../../src/common/fslesl/CM4_4.2/libGFLIB_iar.a; ../../../src/common/fslesl/CM4_4.2/libGMCLIB_iar.a; ../../../src/common/fslesl/CM4_4.2/libMLIB_iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKV46F256xxx16 Freescale MKV46F256xxx16
  ICCARM.CCDefines: CPU_MKV46F256VLL15=1; CLOCK_SETUP=5; ARM_MATH_CM4=1; DEMO=1; NDEBUG=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: as above
  group FSLESL/AMCLIB
    ../../../src/common/fslesl/cm4_4.2/amclib/include/: amclib.h AMCLIB_ACIMFluxObsv_FLT.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_AngleTrackObsrv_FLT.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_PMSMBemfObsrvDQ_FLT.h AMCLIB_TrackObsrv_F32.h AMCLIB_TrackObsrv_FLT.h amclib_types.h
  group FSLESL/GDFLIB
    ../../../src/common/fslesl/cm4_4.2/gdflib/include/: gdflib.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterMA_A32.h gdflib_types.h
  group FSLESL/GFLIB
    ../../../src/common/fslesl/cm4_4.2/gflib/include/: gflib.h GFLIB_CtrlPIp_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h
    ../../../src/common/fslesl/CM4_4.2/gflib/Include/: GFLIB_Atan_A32.h GFLIB_AtanYX_A32.h GFLIB_AtanYXHw_A32.h GFLIB_Hyst_F16.h GFLIB_Lut_F32.h GFLIB_LutPer_F32.h GFLIB_SinCos_A32.h GFLIB_SqrtHw_F16.h GFLIB_SqrtHw_F32.h
  group FSLESL/GMCLIB
    ../../../src/common/fslesl/cm4_4.2/gmclib/include/: gmclib.h GMCLIB_Decoupling_A32.h GMCLIB_Svm_F16.h gmclib_types.h
    ../../../src/common/fslesl/CM4_4.2/gmclib/Include/: GMCLIB_Clark_F16.h GMCLIB_ElimDcBusRip_A32.h GMCLIB_ElimDcBusRip_F16.h GMCLIB_ElimDcBusRipHw_A32.h GMCLIB_ElimDcBusRipHw_F16.h GMCLIB_Park_F16.h
  group FSLESL/MLIB
    ../../../src/common/fslesl/cm4_4.2/mlib/include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Log2_U16.h MLIB_Mac4_F32.h MLIB_Mac4_F32_Asmi.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac_A32.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4_F32_Asmi.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu_A32.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32_Asmi.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_Rcp1Q_A32.h MLIB_Rcp_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h mlib_types.h
    ../../../src/common/fslesl/CM4_4.2/MLIB/Include/: FSLESL_cfg.h MLIB_Add4_F16.h MLIB_Add4_F32.h MLIB_Add_A32_Asmi.h MLIB_BiShift_F16_Asmi.h MLIB_BiShift_F32_Asmi.h MLIB_Clb_F16_Asmi.h MLIB_Clb_F32_Asmi.h MLIB_ConvSc_F32.h MLIB_Div1Q_A32_Asm.h MLIB_Div1Q_F16_Asm.h MLIB_Div1Q_F32_Asm.h MLIB_Div_A32_Asm.h MLIB_Div_F16_Asm.h MLIB_Div_F32_Asm.h MLIB_DivHw1Q_A32.h MLIB_DivHw1Q_F16.h MLIB_DivHw1Q_F32.h MLIB_DivHw_A32.h MLIB_DivHw_F16.h MLIB_DivHw_F32.h MLIB_Log2_U16_Asmi.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F32_Asm.h MLIB_Mac_A32_Asmi.h MLIB_Mac_F16.h MLIB_MacRnd_A32_Asmi.h MLIB_MacRnd_F16.h MLIB_MMDVSQ.h MLIB_Msu4Rnd_F32_Asm.h MLIB_Msu_A32_Asmi.h MLIB_Msu_F16.h MLIB_Msu_F32.h MLIB_MsuRnd_A32_Asmi.h MLIB_MsuRnd_F16.h MLIB_Rcp1Q_A32_Asm.h MLIB_Rcp_A32_Asm.h MLIB_RcpHw1Q_A32.h MLIB_RcpHw_A32.h MLIB_Sat_A32.h MLIB_Sat_A64.h MLIB_Sign_F16.h MLIB_Sign_F32.h MLIB_Sub4_F16.h MLIB_Sub4_F32.h MLIB_Sub_A32_Asmi.h
  group MeterLib/fraclib
    ../../../src/common/meterlib/cm4_4.0/fraclib/Include/: fraclib.h fraclib_inlines.h types.h
  group MeterLib/meterlib
    ../../../src/common/meterlib/cm4_4.0/meterlib/Include/: meterlib.h
  group MeterLib/meterliblp
    ../../../src/common/meterlib/cm4_4.0/meterliblp/Include/: meterliblp.h
  group sdk/CMSIS
    ../../../src/common/sdk/cmsis/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0plus.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group sdk/devices/MKV46F15
    ../../../src/common/sdk/devices/: fsl_device_registers.h startup.c startup.h
  group sdk/devices/MKV46F15/include
    ../../../src/common/sdk/devices/MKV46F15/include/: fsl_bitaccess.h MKV46F15.h MKV46F15_extension.h MKV46F15_features.h
  group sdk/devices/MKV46F15/startup
    ../../../src/common/sdk/devices/MKV46F15/startup/iar/: startup_MKV46F15.s
    ../../../src/common/sdk/devices/MKV46F15/startup/: system_MKV46F15.c system_MKV46F15.h
  group src
    ../../../src/projects/hvp-kv46f/: im_control.c m1_acim_appconfig.h main.c main.h ysADC.c ysADC.h
  group src/board
    ../../../src/projects/hvp-kv46f/board/: app_init.c app_init.h mcdrv_hvp-kv46f.c mcdrv_hvp-kv46f.h
  group src/freemaster
    ../../../src/common/freemaster_drv/: freemaster.h freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_cfg.h freemaster_defcfg.h freemaster_Kxx.c freemaster_Kxx.h freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_sfio.c freemaster_tsa.c freemaster_tsa.h
  group src/mc_algorithms
    ../../../src/common/mc_algorithms/: acim_control.c acim_control.h
  group src/mc_drivers/hvp-kv46f
    ../../../src/common/mc_drivers/: mcdrv_adc_adc12.c mcdrv_adc_adc12.h mcdrv_ftm_pwm3ph.c mcdrv_ftm_pwm3ph.h mcdrv_pwma_pwm3ph.c mcdrv_pwma_pwm3ph.h
  group src/mc_identification/src_common
    ../../../src/common/mc_identification/src_common/: MID_def.h MID_SM_ctrl.c MID_SM_ctrl.h MID_SM_states.c MID_SM_states.h
  group src/mc_identification/src_routines
    ../../../src/common/mc_identification/src_routines/: Blocked_test.c Blocked_test.h Calc_parameters.c Calc_parameters.h Calc_power.c Calc_power.h NoLoad_test.c NoLoad_test.h PwrStg_characteristic.c PwrStg_characteristic.h Rs_measure.c Rs_measure.h
  group src/mc_state_machine
    ../../../src/common/mc_state_machine/: m1_sm_demo.c m1_sm_demo.h
  group src/state_machine
    ../../../src/common/state_machine/: state_machine.c state_machine.h
